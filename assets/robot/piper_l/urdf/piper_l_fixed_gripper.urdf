Commit message: feat: 增加valve例子

File: assets/robot/piper_l/urdf/piper_l_fixed_gripper.urdf (robot description, URDF)
Before this commit: robot piper_l, 12 links, 11 joints
Joints:
- joint tcp_joint: origin xyz=0 0 0.13 rpy=0 -1.5707963 0 -> xyz=0 0 0.11 rpy=0 -1.5707963 0
